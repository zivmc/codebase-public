## Android/hal_examples/kernel/drivers/ebbchar/Kconfig
```kconfig
config EBBCHAR
	tristate "Fake Char Driver"
	default n
	help
	This is the ebbchar driver for android system.
```
